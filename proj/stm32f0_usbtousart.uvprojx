# Keil uVision project stm32f0_usbtousart.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F072C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: stm32f0_usbtousart +hex
  AfterMake: fromelf --bin --output=./bin/stm32f0_usbtousart.bin ./Objects/stm32f0_usbtousart.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,xDEBUG_MSG,STM32F072,USE_STM32072B_EVAL
  c include: ..\module;..\common;..\util;..\user;..\driver;..\driver\board;..\driver\cc1101;..\lib\STM32F0xx_StdPeriph_Driver\inc;..\lib\STM32_USB_Device_Driver\inc;..\lib\STM32_USB_Device_Library\Class\cdc\inc;..\lib\STM32_USB_Device_Library\Core\inc;..\STM32_USB_USER\inc;..\lib\CMSIS\Include;..\lib\CMSIS\Device\ST\STM32F0xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group user
    ../user/: main.c stm32f0xx_it.c
  group module
    ../util/: util_bits.c util_ringbuf.c util_fifo.c
    ../module/: mod_check.c mod_clock.c mod_coils.c mod_console.c mod_key.c mod_leds.c mod_serial.c mod_timers.c
  group lib
    ../lib/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group dirver
    ../driver/: systick.c usart.c eeprom.c
    ../driver/board/: hal_led.c
  group usb_driver
    ../lib/STM32_USB_Device_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group usb_lib
    ../lib/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../lib/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group usb_user
    ../STM32_USB_USER/src/: usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_pwr.c usbd_usr.c
software components: CMSIS:CORE 5.0.1, Device:Startup 2.2.3
